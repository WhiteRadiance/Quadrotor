# Keil uVision project joystick.uvprojx, settings and files
target joystick (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: joystick +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Hardware;..\System\delay;..\System\sys;..\System\usart;..\Core;..\STM32F10x_FWLib\inc;..\FatFs;..\USB_slave\STM32_USB-FS-Device_Driver\inc;..\USB_slave\STM32_USB_Mouse_example;..\MultiMediaFile
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Hardware
    ../Hardware/: IRQHandler.c adc.c key.c led.c exti.c dma.c spi.c oled.c oled_mathpaint.c sdio_sdcard.c si24r1.c timer.c i2c.c
  group FatFs
    ../FatFs/: diskio.c ff.c extfunc.c
    ../FatFs/option/: ccsbcs.c
  group MediaFormat
    ../MultiMediaFile/: PictureLib.c fmt_jpeg.c
  group USB_Driver
    ../USB_slave/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_API
    ../USB_slave/STM32_USB_Mouse_example/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group System
    ../System/delay/: delay.c
    ../System/sys/: sys.c
    ../System/usart/: usart.c
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_dma.c stm32f10x_sdio.c stm32f10x_tim.c
